## tests/fixtures/rk_ble_hid_off/sdkconfig.defaults
```kconfig
CONFIG_COMPILER_OPTIMIZATION_PERF=y
CONFIG_BT_ENABLED=n
CONFIG_RK_BLE_HID_HOST=n
```
